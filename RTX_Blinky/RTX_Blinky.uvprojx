# Keil uVision project RTX_Blinky.uvprojx, settings and files
target STM32F072 Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: RTX_Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Files
    ./: RTX_Blinky.c DAC_DRV.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 2.2.3
